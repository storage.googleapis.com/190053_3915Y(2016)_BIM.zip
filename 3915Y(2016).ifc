Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-20T11:18:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 20 11:18:26 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{D480DC03-27FC-4071-825F-006AA2FE4009}\ifc * Database version: 5507 * Database creation date: Wed Mar 20 11:18:25 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 20 11:18:25 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 20 11:18:25 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3915Y Washbasin faucet, 3915Y(2016):3915Y Washbasin faucet:331747
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 246.5 mm; NominalHeight: 144 mm; NominalWidth: 220.3 mm; Projection: 150 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3915Y(2016); ConvergoRefNr: 0087-1803-0036-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 18/03/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150078194; EN Standard: EN 817
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3915Y; Catalog Drawing URL: http://static.oras.com/catdrw/3915Y; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/3915Y; FDV Document URL: http://www.oras.com/datasheet/3915Y/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3915Y; Group: Washbasin faucets; Long Marketing: Wall-mounted faucet with swivel spout (150 mm) and eccentric unions and cover plates are included. There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: INT;POL;RUS;EST;LTU;LVA;UKR; Model: 3915Y Washbasin faucet; Name_en: 3915Y Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 200 x 165 x 95; Package Weight: 1.537 kg; Product Code: 3915Y; Product Datasheet: http://www.oras.com/datasheet/3915Y/en; Product Family: Oras Saga; Product Image URL: http://static.oras.com/image/3915Y; Product URL: http://static.oras.com/3915Y; Type Name: 3915Y Washbasin faucet; Usage Group: Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection: Covered eccentric unions; Flow: Limitation option for maximum flow rate; Flow Rate At 300kPa: 0.00812237 m3/s; Installation and Maintenance: http://static.oras.com/manual/3915Y; Installation Type: Wall-mounted; Installation Width: CC150± 3 mm; Max. Hot Water Supply: 80 kg/K/s3; Noise Class: I (ISO 3822) Oras lab.; Pressure Loss With Flow 02ls: 230000 Pa; Spare Parts: http://static.oras.com/sp/3915Y; Spout Swivel Range: 360°; Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, utility room; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3915Y(2016); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3915Y; Name: 3915Y Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 194x255x144 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3915Y; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3915Y Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.123287 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00780449 m3
Identity Data - Mark: 11
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3915Y(2016): 3915Y Washbasin faucet; Family and Type: 3915Y(2016): 3915Y Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3915Y(2016): 3915Y Washbasin faucet; Type Id: 3915Y(2016): 3915Y Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
